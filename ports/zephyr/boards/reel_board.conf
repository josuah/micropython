## ports/zephyr/boards/reel_board.conf
```kconfig
# Flash drivers
CONFIG_FLASH=y
CONFIG_FLASH_MAP=y
CONFIG_MPIPEU_ALLOW_FLASH_WRITE=y
```
